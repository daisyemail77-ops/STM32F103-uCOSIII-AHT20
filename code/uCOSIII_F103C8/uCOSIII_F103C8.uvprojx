# Keil uVision project uCOSIII_F103C8.uvprojx, settings and files
target uCOSIII_F103C8 (6180000::V6.18::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uCOSIII_F103C8 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=1 wLevel=2
  c define: STM32F103xB,USE_HAL_DRIVER
  c misc: -ffunction-sections -fdata-sections
  c include: .\;.\HAL\Inc;.\Device\Include;.\Device\CMSIS\Include;.\Middlewares\uC-OS3\Source;.\Middlewares\uC-OS3\Ports;.\Middlewares\uC-OS3\Cfg;.\Middlewares\uC-CPU;.\Middlewares\uC-CPU\Port;.\Middlewares\uC-LIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group 
    ./: main.c app_tasks.c bsp.c aht20.c
    ./HAL/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal_uart.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_i2c.c
    ./Device/Startup/: startup_stm32f103xb.s
    ./Device/Source/: system_stm32f1xx.c
    ./Middlewares/uC-OS3/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
    ./Middlewares/uC-OS3/Ports/: os_cpu_c.c os_cpu_a.asm
    ./Middlewares/uC-OS3/Cfg/: os_app_hooks.c
    ./Middlewares/uC-CPU/: cpu_core.c
    ./Middlewares/uC-CPU/Port/: cpu_c.c cpu_a.asm
    ./Middlewares/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
